# Keil uVision project ossw-weloop.uvprojx, settings and files
target weloop (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ossw-firmware-s120 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_DFU_APP_SUPPORT BLE_STACK_SUPPORT_REQD S110 S120 TARGET_WELOOP SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0 AMX_ANSIONLY
  library: MicroLIB
  memory RVCT4: ROM 0x1d000 size 0x1f000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group Application
    ../../: ossw.c
    ../../target/weloop/: weloop.c weloop.h
  group Libraries
    ../../: ext_flash.c ext_ram.c mlcd.c mlcd_draw.c notifications.c scr_controls.c scr_mngr.c utf8.c vibration.c command.c stopwatch.c watchset.c fs.c accel.c config.c spi_nrf5x.c mcu_nrf5x.c gpio_nrf5x.c timer_nrf5x.c rtc_nrf5x.c battery_nrf5x.c buttons_nrf5x.c
  group Screens
    ../../screens/: scr_alert_notification.c scr_changedate.c scr_changetime.c scr_choosemode.c scr_notifications.c scr_settings.c scr_watchface.c scr_watchset.c scr_watchset_list.c scr_about.c scr_status.c
  group Fonts
    ../../fonts/: big_bold.h big_regular.h font.h normal_bold.h normal_regular.h option_big.h option_normal.h small_bold.h small_regular.h
  group BLE
    ../../ble/: ble_ossw.c ble_central.c ble_peripheral.c
  group PAWN
    ../../pawn/: amx.c amxext.c amxutil.c
  group i18n
    ../../i18n/: i18n.c
  group spiffs
    ../../spiffs/: spiffs_check.c spiffs_gc.c spiffs_hydrogen.c spiffs_nucleus.c spiffs.h spiffs_config.h spiffs_nucleus.h
software components: CMSIS:CORE 3.40.0, Device:Startup 7.2.1, nRF_BLE:BLE_Modules:ble_advdata 3.0.1, nRF_BLE:BLE_Modules:ble_advertising 3.0.1, nRF_BLE:BLE_Modules:ble_common 3.0.1, nRF_BLE:BLE_Modules:ble_conn_params 3.0.1, nRF_BLE:BLE_Modules:ble_db_discovery 3.0.1, nRF_BLE:BLE_Modules:ble_service_common 3.0.1, nRF_BLE:BLE_Modules:device_manager 3.0.1, nRF_BLE:BLE_Services:ble_bas 3.0.1, nRF_BLE:BLE_Services:ble_bas_c 3.0.1, nRF_BLE:BLE_Services:ble_dfu 3.0.1, nRF_BLE:BLE_Services:ble_dis 3.0.1, nRF_BLE:BLE_Services:ble_hrs_c 3.0.1, nRF_Drivers:app_uart 3.0.1, nRF_Drivers:nrf_adc 3.0.1, nRF_Drivers:nrf_delay 3.0.1, nRF_Drivers:nrf_drv_common 3.0.1, nRF_Drivers:nrf_drv_gpiote 3.0.1, nRF_Drivers:nrf_error 3.0.1, nRF_Drivers:nrf_gpio 3.0.1, nRF_Drivers:nrf_gpiote 3.0.1, nRF_Drivers:nrf_soc 3.0.1, nRF_Drivers:pstorage 3.0.1, nRF_Drivers:twi_master 3.0.1, nRF_Libraries:DFU:dfu_app_handler 3.0.1, nRF_Libraries:DFU:dfu_bootloader_util 3.0.1, nRF_Libraries:app_button 3.0.1, nRF_Libraries:app_error 3.0.1, nRF_Libraries:app_fifo 3.0.1, nRF_Libraries:app_timer 3.0.1, nRF_Libraries:app_trace 3.0.1, nRF_Libraries:app_util 3.0.1, nRF_Libraries:nrf_assert 3.0.1, nRF_Libraries:retarget 3.0.1, nRF_SoftDevice:Internal:sd_common 1.1.4, nRF_SoftDevice:Internal:softdevice_present 1.1.4, nRF_SoftDevice:s120 2.1.0
