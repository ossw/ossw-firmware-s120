# Keil uVision project ossw-smaq-nrf51.uvprojx, settings and files
target smaq-nrf51 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ossw-firmware-s120 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD S130 TARGET_SMAQ_NRF51 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0 AMX_ANSIONLY BLE_DFU_APP_SUPPORT
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x20000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group Application
    ../../../target/smaq/: smaq_nrf51.c smaq_nrf51.h
  group Libraries
    ../../../: mcu_nrf5x.c gpio_nrf5x.c timer_nrf5x.c command_rx_buffer.c
  group BLE
    ../../../ble/: ble_ossw.c ble_peripheral.c
software components: CMSIS:CORE 3.40.0, Device:Startup 8.0.3, nRF_BLE:BLE_Modules:ble_advdata 3.0.1, nRF_BLE:BLE_Modules:ble_advertising 3.0.1, nRF_BLE:BLE_Modules:ble_common 3.0.1, nRF_BLE:BLE_Modules:ble_conn_params 3.0.1, nRF_BLE:BLE_Modules:ble_db_discovery 3.0.1, nRF_BLE:BLE_Modules:ble_service_common 3.0.1, nRF_BLE:BLE_Modules:device_manager 3.0.1, nRF_BLE:BLE_Services:ble_bas 3.0.1, nRF_BLE:BLE_Services:ble_bas_c 3.0.1, nRF_BLE:BLE_Services:ble_cscs 3.0.1, nRF_BLE:BLE_Services:ble_dfu 3.0.1, nRF_BLE:BLE_Services:ble_dis 3.0.1, nRF_BLE:BLE_Services:ble_hrs_c 3.0.1, nRF_BLE:BLE_Services:ble_sc_ctrlpt 3.0.1, nRF_Drivers:app_uart 3.0.1, nRF_Drivers:nrf_adc 3.0.1, nRF_Drivers:nrf_delay 3.0.1, nRF_Drivers:nrf_drv_common 3.0.1, nRF_Drivers:nrf_drv_gpiote 3.0.1, nRF_Drivers:nrf_error 3.0.1, nRF_Drivers:nrf_gpio 3.0.1, nRF_Drivers:nrf_gpiote 3.0.1, nRF_Drivers:pstorage 3.0.1, nRF_Drivers:spi_slave 3.0.1, nRF_Drivers:twi_master 3.0.1, nRF_Libraries:DFU:dfu_app_handler 3.0.1, nRF_Libraries:DFU:dfu_bootloader_util 3.0.1, nRF_Libraries:app_button 3.0.1, nRF_Libraries:app_error 3.0.1, nRF_Libraries:app_timer 3.0.1, nRF_Libraries:app_trace 3.0.1, nRF_Libraries:app_util 3.0.1, nRF_Libraries:nordic_common 3.0.1, nRF_Libraries:nrf_assert 3.0.1, nRF_Libraries:retarget 3.0.1, nRF_Libraries:sensorsim 3.0.1, nRF_SoftDevice:Internal:sd_common 1.1.4, nRF_SoftDevice:Internal:softdevice_present 1.1.4, nRF_SoftDevice:s130 1.0.1
