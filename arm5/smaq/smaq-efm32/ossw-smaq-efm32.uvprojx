# Keil uVision project ossw-smaq-efm32.uvprojx, settings and files
target smaq-efm32 (ARM-ADS)
  device: EFM32GG330F512 Silicon Labs
  pack: Keil.EFM32GGxxx_DFP.2.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ossw-smaq-efm32
  AfterMake: fromelf.exe --bin --output obj\ossw-smaq-efm32.bin obj\ossw-smaq-efm32.axf
  c flags: Optim=4 oTime=1
  c define: EFM32GG330F512 TARGET_SMAQ_EFM32 BLE_STACK_SUPPORT_REQD S130 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\EnergyMicro\EFM32GG\Include;..\..\..\emlib\inc;..\..\..\kits\common\drivers;..\..\..\kits\common\bsp;..\..\..\kits\EFM32GG_DK3750\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x4100 size 0x5ff00
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ../../../target/smaq/: smaq_efm32.c smaq_efm32.h
    ../../../: ossw.c
  group Libraries
    ../../../: mcu_efm32.c utf8.c mlcd_draw.c notifications.c command.c timer_efm32.c buttons_efm32.c ext_flash.c fs.c gpio_efm32.c rtc_efm32.c scr_controls.c scr_mngr.c spi_efm32.c stopwatch.c vibration.c watchset.c config.c battery_efm32.c ext_ram_fake.c mlcd.c command_rx_buffer.c
    ../../../ble/: ble_peripheral_efm32.c
  group Screens
    ../../../screens/: scr_about.c scr_alert_notification.c scr_changedate.c scr_changetime.c scr_choosemode.c scr_notifications.c scr_settings.c scr_status.c scr_watchface.c scr_watchset.c scr_watchset_list.c
  group Fonts
    ../../../fonts/: big_bold.h big_regular.h font.h normal_bold.h normal_regular.h option_big.h option_normal.h small_bold.h small_regular.h
  group i18n
    ../../../i18n/: i18n.c messages_en.h
  group spiffs
    ../../../spiffs/: spiffs_check.c spiffs_gc.c spiffs_hydrogen.c spiffs_nucleus.c
software components: CMSIS:CORE 3.40.0, Device:Startup 4.0.0, Device:emdrv:GPIOINT 4.0.0, Device:emdrv:RTCDRV 4.0.0, Device:emdrv:SLEEP 4.0.0, Device:emlib:CMU 4.0.0, Device:emlib:DMA 4.0.0, Device:emlib:EBI 4.0.0, Device:emlib:EMU 4.0.0, Device:emlib:Framework 4.0.0, Device:emlib:GPIO 4.0.0, Device:emlib:INT 4.0.0, Device:emlib:RMU 4.0.0, Device:emlib:RTC 4.0.0, Device:emlib:SYSTEM 4.0.0, Device:emlib:USART 4.0.0
